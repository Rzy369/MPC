Commit message: test the environment

File: environment/model/obstacle1.urdf (robot description, URDF)
Before this commit: robot wall2, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=1 1 1; visual cylinder length=0.2 radius=0.2
